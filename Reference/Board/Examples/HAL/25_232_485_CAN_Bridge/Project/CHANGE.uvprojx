# Keil uVision project CHANGE.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CHANGE +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4xx_HAL_Driver\inc;..\USER\LED;..\USER\LCD;..\USER\BEEP;..\USER\KEY;..\USER\LCD;..\USER\usart1;..\USER\RS485;..\USER\CAN;..\USER\CHANGE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: system_stm32f4xx.c stm32f4xx_hal_msp.c startup_stm32f407xx.s cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h
  group USER
    ../USER/LED/: led.c
    ../USER/BEEP/: beep.c
    ../USER/KEY/: key.c
    ../USER/LCD/: lcd.c
    ../USER/usart1/: usart1.c
    ../USER/CAN/: can1.c can2.c
    ../USER/RS485/: rs485.c
    ../USER/CHANGE/: change.c
  group STM32F4_HAL_FWLIB
    ../STM32F4xx_HAL_Driver/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_usart.c stm32f4xx_hal_uart.c stm32f4xx_hal_can.c
  group Common
    ../Common/: common.c
software components: CMSIS:CORE 4.3.0
