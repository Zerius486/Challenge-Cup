# Keil uVision project LWIP.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LWIP +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4_FWLIB\inc;..\USER\LCD;..\USER\LED;..\USER\usart1;..\USER\KEY;..\USER\LAN8720;..\USER\LWIP_APP;..\STM32F4x7_ETH_Driver\inc;..\MALLOC;..\USER\TIMER;..\LWIP;..\LWIP\arch;..\LWIP\lwip-1.4.1;..\LWIP\lwip-1.4.1\src;..\LWIP\lwip-1.4.1\test;..\LWIP\lwip-1.4.1\src\api;..\LWIP\lwip-1.4.1\src\core;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\netif;..\LWIP\lwip-1.4.1\test\unit;..\LWIP\lwip_app\lwip_base;..\LWIP\lwip_app\udp_demo;..\MALLOC;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\USER\usart1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group USER
    ../USER/LCD/: lcd.c
    ../USER/LED/: led.c
    ../USER/KEY/: key.c
    ../USER/TIMER/: timer.c
    ../USER/usart1/: usart1.c
    ../USER/LAN8720/: lan8720.c
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_pwr.c
    ../STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group MALLOC
    ../MALLOC/: malloc.c
  group Common
    ../Common/: common.c
  group LWIP_APP
    ../LWIP/lwip_app/lwip_base/: lwip_base.c
    ../LWIP/lwip_app/udp_demo/: udp_demo.c
  group LWIP_API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP_CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: lwip_sys.c def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
    ../LWIP/arch/: sys_arch.c
software components: CMSIS:CORE 4.3.0
